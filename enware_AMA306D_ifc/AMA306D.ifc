Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2021-11-15T12:05:07
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150220_1215(x64) - Exporter 16.0.2.1 - Alternate UI 16.0.2.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Nov 15 12:05:07 2021 * Host: PC-031 * Database: C:\Users\PC-031\AppData\Local\Temp\{6C259D83-D18B-449C-A2BD-FD979A2E5449}\ifc * Database version: 5507 * Database creation date: Mon Nov 15 12:05:06 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Nov 15 12:05:07 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Nov 15 12:05:07 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: \\192.168.1.99\Vol-2-New\MEP\13. Mark N\Plumbing Fixture\Working\AMA306D.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: AMA306D, AMA306D:AMA306D:3361
In: Level 1
Pset_BuildingElementProxyCommon - Reference: AMA306D
Pset_ManufacturerTypeInformation - Manufacturer: Standard 5 Star WELS (5.7 lpm) laminar, Optional 5 Star (5.5 lpm), 6 Star WELS (3 lpm) aerators supplied
